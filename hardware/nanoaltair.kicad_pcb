# Repository dankar/nanoaltair8800

File README.md:

nanoAltair
==========

This is a continuation and remake of my old Altair8800 project (https://github.com/dankar/altair8800)

The Intel 8080 emulation is much improved, the PCB is credit card sized and it contains all the processing power required on board. Micro USB connector provides power, serial port and firmware updates.

This is still a work in progress, and there might be both hardware and software bugs. This documentation should be accurate, but there might be changes that haven't been added to the documentation yet. If in doubt, check the code and build scripts.

License
=======
Hardware design and code is covered by the LICENSE.md file. Files under software/stm32cube are generated by STM32CubeMX and subject to their own license.

Firmware update
===============
The current firmware build can be shown by connecting to the USB virtual com port and pressing the examine button while the stop button is being held down. The build version and timestamp will then be printed over the com port.

Firmware update can be initiated by connecting via USB and then pressing the reset button while the stop button is being held down.  The device will then appear as a DFU device and firmware update can proceed. STM32 DFU driver might have to be installed on your PC.

Basic operation
===============
The stop and run buttons will change between stopped and running modes. When in running mode the CPU will continually fetch new instructions and execute them. No buttons except for stop will have any effect.

When in stopped mode the rest of the buttons can be used. Reset will completely reset all memory, and parse the configuration file again, reopening any disk files and load any ROMs.

Examine will read the state of the DIP switches and load that address in ROM/RAM. The address LEDs will be updated to show this address and the data LEDs will show the byte stored in that address. Examine next will increment the address being examined by one.

Deposit and deposit next will put the low byte of the DIP switches into the currently examined address location, or the next address location respectively.

Step will execute one instruction and then return to stopped mode. Note that this differs from the original Altair, where the step switch executed one machine cycle.

SD card
=======
The SD card needs to be formatted with a FAT file system. Both FAT32 and exFAT is fine. Long file names are supported, but everything probably works best if no special characters are used in filenames.

Configuration file
==================
Upon reset the emulator will try to find "altair.cfg" in the root of the SD-card. This will then be parsed to determine the setup and optional other files to be loaded. Each line in the configuration file is one setting, except for empty lines or line beginning with #, which are for comments.

A setting consists of first a name for the setting, then an equal sign and lastly the value of the setting.

The configuration file is read top-down and if there are duplicates of any setting, the last one will apply. The default_path setting is special since it affects file loading during the parsing of the configuration file and will be active until another value is set as the default path.

Do note that it is perfectly possible to start the emulator without a valid configuration file, and even without an SD card inserted. The emulator will warn about this by flashing the front panel lights in a sequence, but after this data can be input via the front panel. Since no port I/O will be setup without a configuration, the functionality is very limited in this mode.

Settings
--------

### default_path = [path]

This can be used to set a path prefix for any subsequent file loads. It is entirely optional as the full paths to the files can be specified instead. Setting this setting to a value of "." will set the root folder as default.

### disk[0-3] = [path/filename.ext]

This command is used to load a file as a virtual floppy disk. A maximum number of four disks can be mounted at the same time, using settings disk[0], disk[1], disk[2] and disk[3]. The disks will be available through the emulated 88-DCDD device.

### tape = [path/filename.ext]

Used to mount a file as a tape, attached to serial port two of the emulated 88-2SIO device.

### port[HEX] = [port_name]

Used to assign specific input/output functions to specific port number. The port numbers are specified in hexadecimal numbers, without any prefix or suffix.

The following port names are available:

#### serial1_control

Control/status for serial port one of the 88-2SIO.

#### serial1_data

Data in/out for serial port one of the 88-2SIO

#### serial2_control

Control/status for serial port two of the 88-2SIO.

#### serial2_data

Data in/out for serial port two of the 88-2SIO. Note that this data port is by default connected to any mounted tape file, making it possible to load program from tape by loading from serial port two.

#### sense_sw

Port input for the front panel sense switches. These should always be on port FF.

#### floppy_select_status

Select/status functions of the 88-DCDD disk drive.

#### floppy_function_sector

Function/sector functions of the 88-DCDD disk drive.

#### floppy_data

Data input/output functions of the 88-DCDD disk drive.

#### vic

Control function for the 88-VI/RTC, combined vectored interrupt and RTC controller.

### rom[HEX] = [path/filename.ext]

Used to specify a ROM to be loaded at an offset in memory specified by a hexadecimal offset. Any loaded ROMs will be disabled as soon as any data in or out is detected on port FF. After this, all 64k of RAM are available.

### start_address = [HEX]

This specifies the address that the CPU will be waiting on after a reset.

### run_state = [true/false]

This specifies whether the CPU should start halted or if it should start executing directly after a reset.

### rtc_divider = [number]

This specifies how to divide the 60 Hz clock running the RTC interrupt on the vectored interrupt controller. Setting this to 1 will generate an interrupt 60 times a second.

### rtc_interrupt_line = [number]

This sets which interrupt line on the vectored interrupt controller to use for the RTC.

### serial1_interrupt_line = [number]

This sets which interrupt line on the vectored interrupt controller to use for the first serial port.

Example configuration
---------------------

```
# Use cpm22 as default path
default_path = cpm22

# Load bootable cpm image as disk0
disk[0] = cpm63k.dsk

# Load games as disk1
disk[1] = games.dsk

# Change default path to the folder with tapes
default_path = tapes
# Load a tape with extended basic
tape = extbasic.tap

# Load some ROMs that we want to have
#
# turmonh is the Turnkey Monitor, with the added command H, for 
# loading Intel Hex files via the monitor.
# 
# mble is the bootloader for loading programs from tape
#
# dbl is the disk bootloader.
# 
default_path = roms
rom[fd00] = turmonh.bin
rom[fe00] = mble.bin
rom[ff00] = dbl.bin

# Set some default values for the interrupt lines and RTC divider
rtc_divider = 1
rtc_interrupt_line = 6
serial1_interrupt_line = 7

# Set the port I/O to a good default configuration. This should most 
# likely be the same for any most configurations.
port[00] = serial1_control
port[01] = serial1_data
port[08] = floppy_select_status
port[09] = floppy_function_sector
port[0A] = floppy_data
port[10] = serial1_control
port[11] = serial1_data
port[12] = serial2_control
port[13] = serial2_data
port[FE] = vic
port[FF] = sense_sw
```

Booting from disk
=================

Using the above example configuration, the system can be booted from disk[0] by first entering FF00 on the front switches, then pressing examine to go to that offset (the start of the DBL ROM) and then hitting run. The terminal will be on serial port one, available via the USB virtual com port.

Booting from tape
=================

Using the above example configuration, extended basic can be loaded from tape by first entering FE00 on the front switches, and pressing examine to go to that offset. The CPU will now be halted at the beginning of the MBL bootloader. Before hitting run, make sure to set up the sense switches (A15-A8) as needed. 

In this case we set the lower three switches to 110 to tell the bootloader to load tape from serial port two (001 would load tape from the USB virtual com port) and the high four switches to 0001 so that BASIC will know to use serial port one as terminal. After this we can press run and BASIC will be loaded from tape.

Building the firmware
=====================

Project is built with cmake:

```
apt install cmake git zip gcc gcc-arm-none-eabi make
mkdir build
cd build
cmake ..
make -j
```

Alternatively, you can use docker to build by simply running:

```
./build.sh all
```

And if you want a packaged release, run:

```
./build.sh create_release
```

## KiCad design hardware/nanoaltair.kicad_pcb

Parts:
C1, C2: 10u; C_0805_2012Metric
C3: 1u; C_0805_2012Metric
C5, C6, C7, C8, C9: 100n; C_0805_2012Metric
C10: 4.7u; C_0805_2012Metric
D1: D; D_SOD-323
F1: Polyfuse; R_1206_3216Metric
J1: Conn_01x09; EdgeConn1x09
J2: USB_B_Micro; USB_Micro-B_Amphenol_10103594-0001LF_Horizontal
J4: Micro_SD_Card_Det; microSD_HC_Hirose_DM3BT-DSF-PEJS
R1, R36, R37, R38, R39, R40, R41, R42: 10; R_0805_2012Metric
R2: 22; R_0805_2012Metric
R3: 10k; R_0805_2012Metric
SW1: AddLow; CT3121CT-ND
SW2: AddHigh; CT3121CT-ND
SW3: Stop; SW_SPST_TL3342
SW4: Run; SW_SPST_TL3342
SW5: Step; SW_SPST_TL3342
SW6: Reset; SW_SPST_TL3342
SW7: Examine; SW_SPST_TL3342
SW8: Examine Next; SW_SPST_TL3342
SW9: Deposit; SW_SPST_TL3342
SW10: Deposit Next; SW_SPST_TL3342
U1: TLV1117-33; SOT-223-3_TabPin2
U2: STM32L496RETx; LQFP-64_10x10mm_P0.5mm

Connections:
/3.3V: C2.1, C3.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, D1.2 (A), J4.4 (VDD), R1.2, U1.2 (VO), U2.1 (VBAT), U2.13 (VDDA), U2.19 (VDD), U2.32 (VDD), U2.48 (VDDUSB), U2.64 (VDD); also elsewhere on the board
/ADDRESS_SWITCH_1: SW1.9, U2.26 (PB0)
/ADDRESS_SWITCH_2: SW1.10, U2.25 (PC5)
/ADDRESS_SWITCH_3: SW1.11, U2.24 (PC4)
/ADDRESS_SWITCH_4: SW1.12, U2.20 (PA4)
/ADDRESS_SWITCH_5: SW1.13, U2.17 (PA3)
/ADDRESS_SWITCH_6: SW1.14, U2.16 (PA2)
/ADDRESS_SWITCH_7: SW1.15, U2.15 (PA1)
/ADDRESS_SWITCH_8: SW1.16, U2.14 (PA0)
/ADDRESS_SWITCH_9: SW2.9, U2.8 (PC0)
/ADDRESS_SWITCH_10: SW2.10, U2.4 (PC15)
/ADDRESS_SWITCH_11: SW2.11, U2.3 (PC14)
/ADDRESS_SWITCH_12: SW2.12, U2.62 (PB9)
/ADDRESS_SWITCH_13: SW2.13, U2.61 (PB8)
/ADDRESS_SWITCH_14: SW2.14, U2.59 (PB7)
/ADDRESS_SWITCH_15: SW2.15, U2.58 (PB6)
/ADDRESS_SWITCH_16: SW2.16, U2.57 (PB5)
/BOOT0: R2.2, R3.1, U2.60 (PH3)
/DEPOSIT_NEXT_SW: SW10.1, U2.33 (PB12)
/DEPOSIT_SW: SW9.1, U2.28 (PB2)
/EXAMINE_NEXT_SW: SW8.1, U2.34 (PB13)
/EXAMINE_SW: SW7.1, U2.35 (PB14)
/LED_LATCH: U2.41 (PA8); also elsewhere on the board
/RESET: R41.2, U2.7 (NRST)
/RESET_SW: SW6.1, U2.27 (PB1)
/RUN_SW: SW4.1, U2.36 (PB15)
/SD_CD: J4.10 (DET_A), U2.2 (PC13)
/SD_CLK: J4.5 (CLK), U2.53 (PC12)
/SD_CMD: J4.3 (CMD), U2.54 (PD2)
/SD_DAT0: J4.7 (DAT0), U2.39 (PC8)
/SD_DAT1: J4.8 (DAT1), U2.40 (PC9)
/SD_DAT2: J4.1 (DAT2), U2.51 (PC10)
/SD_DAT3: J4.2 (DAT3/CD), U2.52 (PC11)
/SPI1_CLK: U2.21 (PA5); also elsewhere on the board
/SPI1_MOSI: U2.23 (PA7); also elsewhere on the board
/STEP_SW: SW5.1, U2.38 (PC7)
/STOP_SW: SW3.1, U2.37 (PC6)
/SWCLK: R37.2, U2.49 (PA14)
/SWDAT: R36.2, U2.46 (PA13)
/TDI: R38.2, U2.50 (PA15)
/TDO: R39.2, U2.55 (PB3)
/TRST: R40.2, U2.56 (PB4)
/USB_DM: J2.2, U2.44 (PA11)
/USB_DP: J2.3, U2.45 (PA12)
/USB_ID: J2.4, U2.43 (PA10)
/VBUS: F1.1, J2.1, U2.42 (PA9)
/VFUSED: C1.1, D1.1 (K), F1.2, U1.3 (VI)
GND: C1.2, C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, J2.5, J2.6, J4.6 (VSS), J4.9 (DET_B), J4.11 (SHIELD), R3.2, R42.2, SW1.1, SW1.2, SW1.3, SW1.4, SW1.5, SW1.6, SW1.7, SW1.8, SW2.1, SW2.2, SW2.3, SW2.4, SW2.5, SW2.6, SW2.7, SW2.8, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, U1.1 (GND), U2.12 (VSSA), U2.18 (VSS), U2.31 (VSS), U2.47 (VSS), U2.63 (VSS); also elsewhere on the board
unnamed: J1.1, R2.1
unnamed: J1.2, R1.1
unnamed: J1.3, R36.1
unnamed: J1.4, R37.1
unnamed: J1.5, R38.1
unnamed: J1.6, R39.1
unnamed: J1.7, R40.1
unnamed: J1.8, R41.1
unnamed: J1.9, R42.1

Parts:
D2: ADDRESS8; LED_0805_2012Metric
D3: ADDRESS16; LED_0805_2012Metric
D4: ADDRESS7; LED_0805_2012Metric
D5: ADDRESS15; LED_0805_2012Metric
D6: ADDRESS6; LED_0805_2012Metric
D7: ADDRESS14; LED_0805_2012Metric
D8: ADDRESS5; LED_0805_2012Metric
D9: ADDRESS13; LED_0805_2012Metric
D10: ADDRESS4; LED_0805_2012Metric
D11: ADDRESS12; LED_0805_2012Metric
D12: ADDRESS3; LED_0805_2012Metric
D13: ADDRESS11; LED_0805_2012Metric
D14: ADDRESS2; LED_0805_2012Metric
D15: ADDRESS10; LED_0805_2012Metric
D16: ADDRESS1; LED_0805_2012Metric
D17: ADDRESS9; LED_0805_2012Metric
D18: DATA8; LED_0805_2012Metric
D19: STATUS8; LED_0805_2012Metric
D20: DATA7; LED_0805_2012Metric
D21: STATUS7; LED_0805_2012Metric
D22: DATA6; LED_0805_2012Metric
D23: STATUS6; LED_0805_2012Metric
D24: DATA5; LED_0805_2012Metric
D25: STATUS5; LED_0805_2012Metric
D26: DATA4; LED_0805_2012Metric
D27: STATUS4; LED_0805_2012Metric
D28: DATA3; LED_0805_2012Metric
D29: STATUS3; LED_0805_2012Metric
D30: DATA2; LED_0805_2012Metric
D31: STATUS2; LED_0805_2012Metric
D32: DATA1; LED_0805_2012Metric
D33: STATUS1; LED_0805_2012Metric
R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35: R; R_0805_2012Metric
U3, U4, U5, U6: 74HC595; SO-16_3.9x9.9mm_P1.27mm

Connections:
/3.3V: U3.10 (~SRCLR), U3.16 (VCC), U4.10 (~SRCLR), U4.16 (VCC), U5.10 (~SRCLR), U5.16 (VCC), U6.10 (~SRCLR), U6.16 (VCC); also elsewhere on the board
/LED_LATCH: U3.12 (RCLK), U4.12 (RCLK), U5.12 (RCLK), U6.12 (RCLK); also elsewhere on the board
/SPI1_CLK: U3.11 (SRCLK), U4.11 (SRCLK), U5.11 (SRCLK), U6.11 (SRCLK); also elsewhere on the board
/SPI1_MOSI: U3.14 (SER); also elsewhere on the board
GND: D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), U3.8 (GND), U3.13 (~OE), U4.8 (GND), U4.13 (~OE), U5.8 (GND), U5.13 (~OE), U6.8 (GND), U6.13 (~OE); also elsewhere on the board
unnamed: D2.2 (A), R4.1
unnamed: D3.2 (A), R5.1
unnamed: D4.2 (A), R6.1
unnamed: D5.2 (A), R7.1
unnamed: D6.2 (A), R8.1
unnamed: D7.2 (A), R9.1
unnamed: D8.2 (A), R10.1
unnamed: D9.2 (A), R11.1
unnamed: D10.2 (A), R12.1
unnamed: D11.2 (A), R13.1
unnamed: D12.2 (A), R14.1
unnamed: D13.2 (A), R15.1
unnamed: D14.2 (A), R16.1
unnamed: D15.2 (A), R17.1
unnamed: D16.2 (A), R18.1
unnamed: D17.2 (A), R19.1
unnamed: D18.2 (A), R20.1
unnamed: D19.2 (A), R21.1
unnamed: D20.2 (A), R22.1
unnamed: D21.2 (A), R23.1
unnamed: D22.2 (A), R24.1
unnamed: D23.2 (A), R25.1
unnamed: D24.2 (A), R26.1
unnamed: D25.2 (A), R27.1
unnamed: D26.2 (A), R28.1
unnamed: D27.2 (A), R29.1
unnamed: D28.2 (A), R30.1
unnamed: D29.2 (A), R31.1
unnamed: D30.2 (A), R32.1
unnamed: D31.2 (A), R33.1
unnamed: D32.2 (A), R34.1
unnamed: D33.2 (A), R35.1
unnamed: R4.2, U3.7 (QH)
unnamed: R5.2, U4.7 (QH)
unnamed: R6.2, U3.6 (QG)
unnamed: R7.2, U4.6 (QG)
unnamed: R8.2, U3.5 (QF)
unnamed: R9.2, U4.5 (QF)
unnamed: R10.2, U3.4 (QE)
unnamed: R11.2, U4.4 (QE)
unnamed: R12.2, U3.3 (QD)
unnamed: R13.2, U4.3 (QD)
unnamed: R14.2, U3.2 (QC)
unnamed: R15.2, U4.2 (QC)
unnamed: R16.2, U3.1 (QB)
unnamed: R17.2, U4.1 (QB)
unnamed: R18.2, U3.15 (QA)
unnamed: R19.2, U4.15 (QA)
unnamed: R20.2, U5.7 (QH)
unnamed: R21.2, U6.7 (QH)
unnamed: R22.2, U5.6 (QG)
unnamed: R23.2, U6.6 (QG)
unnamed: R24.2, U5.5 (QF)
unnamed: R25.2, U6.5 (QF)
unnamed: R26.2, U5.4 (QE)
unnamed: R27.2, U6.4 (QE)
unnamed: R28.2, U5.3 (QD)
unnamed: R29.2, U6.3 (QD)
unnamed: R30.2, U5.2 (QC)
unnamed: R31.2, U6.2 (QC)
unnamed: R32.2, U5.1 (QB)
unnamed: R33.2, U6.1 (QB)
unnamed: R34.2, U5.15 (QA)
unnamed: R35.2, U6.15 (QA)
unnamed: U3.9 (QH'), U4.14 (SER)
unnamed: U4.9 (QH'), U5.14 (SER)
unnamed: U5.9 (QH'), U6.14 (SER)

Board: 2 copper layers, 85.6 x 53.8 mm, 104 parts (61 on the bottom side), 124 nets.

## Code that names these connections

File software/stm32cube/Core/Src/main.c (part):

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  __HAL_RCC_GPIOD_CLK_ENABLE();

  /*Configure GPIO pin Output Level */
  HAL_GPIO_WritePin(LED_LATCH_GPIO_Port, LED_LATCH_Pin, GPIO_PIN_RESET);

  /*Configure GPIO pins : SD_CD_Pin ADDRESS_11_Pin ADDRESS_10_Pin ADDRESS_9_Pin
                           ADDRESS_3_Pin ADDRESS_2_Pin */
  GPIO_InitStruct.Pin = SD_CD_Pin|ADDRESS_11_Pin|ADDRESS_10_Pin|ADDRESS_9_Pin
                          |ADDRESS_3_Pin|ADDRESS_2_Pin;
  GPIO_InitStruct.Mode = GPIO_MODE_INPUT;
  GPIO_InitStruct.Pull = GPIO_PULLUP;
  HAL_GPIO_Init(GPIOC, &GPIO_InitStruct);

  /*Configure GPIO pins : PH0 PH1 PH3 */
  GPIO_InitStruct.Pin = GPIO_PIN_0|GPIO_PIN_1|GPIO_PIN_3;
  GPIO_InitStruct.Mode = GPIO_MODE_ANALOG;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
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  GPIO_InitStruct.Pull = GPIO_PULLUP;
  HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);

  /*Configure GPIO pins : PA6 PA10 */
  GPIO_InitStruct.Pin = GPIO_PIN_6|GPIO_PIN_10;
  GPIO_InitStruct.Mode = GPIO_MODE_ANALOG;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
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  GPIO_InitStruct.Pull = GPIO_PULLUP;
  HAL_GPIO_Init(GPIOB, &GPIO_InitStruct);

  /*Configure GPIO pins : RESET_SW_Pin DEPOSIT_SW_Pin DEPOSIT_NEXT_SW_Pin EXAMINE_NEXT_SW_Pin
                           EXAMINE_SW_Pin RUN_SW_Pin */
  GPIO_InitStruct.Pin = RESET_SW_Pin|DEPOSIT_SW_Pin|DEPOSIT_NEXT_SW_Pin|EXAMINE_NEXT_SW_Pin
                          |EXAMINE_SW_Pin|RUN_SW_Pin;
  GPIO_InitStruct.Mode = GPIO_MODE_IT_RISING_FALLING;
  GPIO_InitStruct.Pull = GPIO_PULLUP;
  HAL_GPIO_Init(GPIOB, &GPIO_InitStruct);
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  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(GPIOB, &GPIO_InitStruct);

  /*Configure GPIO pins : STOP_SW_Pin STEP_SW_Pin */
  GPIO_InitStruct.Pin = STOP_SW_Pin|STEP_SW_Pin;
  GPIO_InitStruct.Mode = GPIO_MODE_IT_RISING_FALLING;
  GPIO_InitStruct.Pull = GPIO_PULLUP;
  HAL_GPIO_Init(GPIOC, &GPIO_InitStruct);

  /*Configure GPIO pin : LED_LATCH_Pin */
  GPIO_InitStruct.Pin = LED_LATCH_Pin;
  GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_LOW;
  HAL_GPIO_Init(LED_LATCH_GPIO_Port, &GPIO_InitStruct);

  /* EXTI interrupt init*/
  HAL_NVIC_SetPriority(EXTI1_IRQn, 0, 0);
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
## Commit log

2021-04-04 Wrong path in readme
2021-04-26 Updated testing and fixed strict aliasing error
2021-04-26 Removed faulty release
2021-04-26 Generate scripts
2021-04-26 Fix dependency
2021-04-26 Get release name from tag
2021-04-26 Added release workflow
2021-04-26 Removed old files
2021-04-26 Temporary lower test level
2021-04-26 Upped the test level again
2021-04-26 Fix makefile
2021-05-11 Prettified makefile output
2021-05-11 Added dockerfile for building the software.
2021-05-12 Fixed docker to use mounted volume for project files, and correct user/group set on build files.
2021-05-12 Modified workflow to use docker build
2021-05-12 Added CI to development branch
2021-05-12 Fixed workflow
2021-05-12 Updated release workflow to use docker build
2021-05-12 First test of daemon
2021-05-13 Added front-end
2021-05-13 Added sleep
2021-05-13 Added missing files
2021-05-13 Missing files
2021-05-13 Updated sleep value
2021-05-14 Modified cycle time
2021-05-14 Further tweaking
2021-05-14 More tweaks
2021-05-14 Added control API and reset function
2021-05-14 Added \r to enter key
2021-05-14 Reverted \r...
2021-05-14 Added real terminal emulation
2021-05-14 Added some better disks to emulator
2021-05-14 Tweak speed again
2021-05-19 First commit of cmake stuff
2021-05-20 CMake build of firmware now working
2021-05-20 Added CMake project for tests
2021-05-20 Integrated tests when building
2021-05-20 Fixed: syscall bindings for newlib was missing
2021-05-20 Moved hardware project from unnecessary subfolder
2021-05-20 New Dockerfile for building with cmake
2021-11-02 Updated readme with new build instructions

Notices in the files:
software/stm32cube/Core/Src/main.c:
© Copyright (c) 2020 STMicroelectronics.
All rights reserved.
This software component is licensed by ST under Ultimate Liberty license
(C) COPYRIGHT STMicroelectronics *****END OF FILE
